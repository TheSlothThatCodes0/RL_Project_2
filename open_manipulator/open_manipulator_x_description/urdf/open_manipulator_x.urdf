Commit message: gripper working!

File: open_manipulator/open_manipulator_x_description/urdf/open_manipulator_x.urdf (robot description, URDF)
Before this commit: robot open_manipulator_x, 10 links, 9 joints
Joints:
- joint world_fixed: type fixed -> revolute
